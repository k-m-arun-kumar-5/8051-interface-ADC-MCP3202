# Keil uVision project MCP3202_ADC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MCP3202_ADC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 constants.h io_conf.h lcd.h main.h mcp3202.h port.h lcd.c main.c mcp3202.c uart.c
